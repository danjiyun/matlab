# IAR project matlab.ewp, settings and files
configuration max35103evkit2 (ARM, debug)
  General.OGChipSelectEditMenu: MAX32620 Maxim MAX32620
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TARGET=max32620; TARGET_REV=0x4332; MAX35103
  ICCARM.CCIncludePath2: ..; ..\board\max35103evkit2\; ..\board\max35103evkit2\csl\CMSIS\Include; ..\board\max35103evkit2\csl\CMSIS\Device\Maxim\MAX32620\Include; ..\board\max35103evkit2\csl\PeriphDriver\Include; ..\board\max35103evkit2\max3510x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: com.c com.h global.h main.c serialize.c serialize.h
  group board
    ../board/max35103evkit2/: board.c transducer.c transducer.h
  group board/CSL
    ../board/max35103evkit2/csl/PeriphDriver/Source/: adc.c aes.c clkman.c crc.c flc.c gpio.c i2cm.c i2cs.c icc.c ioman.c lp.c maa.c mxc_assert.c mxc_lock.c mxc_sys.c nvic_table.c owm.c pmu.c prng.c pt.c rtc.c spim.c spis.c spix.c tmr.c tmr_utils.c uart.c wdt.c wdt2.c
    ../board/max35103evkit2/csl/PeriphDriver/Include/: adc.h aes.h clkman.h crc.h flc.h gpio.h i2cm.h i2cs.h icc.h ioman.h lp.h maa.h mxc_assert.h mxc_config.h mxc_errors.h mxc_lock.h mxc_sys.h nvic_table.h owm.h pmu.h prng.h pt.h rtc.h spim.h spis.h spix.h tmr.h tmr_utils.h uart.h wdt.h wdt2.h
    ../board/max35103evkit2/csl/CMSIS/Device/Maxim/MAX32620/Include/: adc_regs.h aes_regs.h clkman_regs.h crc_regs.h flc_regs.h gpio_regs.h i2cm_regs.h i2cs_regs.h icc_regs.h ioman_regs.h maa_regs.h max32620.h max32620.svd mxc_device.h owm_regs.h pmu_regs.h prng_regs.h pt_regs.h pwrman_regs.h pwrseq_regs.h rtc_regs.h spib_regs.h spim_regs.h spis_regs.h spix_regs.h sysman_regs.h system_max32620.h tmr_regs.h tpu_regs.h trim_regs.h uart_regs.h usb_regs.h wdt2_regs.h wdt_regs.h
    ../board/max35103evkit2/csl/CMSIS/Device/Maxim/MAX32620/Source/IAR/: startup_max32620.s
    ../board/max35103evkit2/csl/CMSIS/Device/Maxim/MAX32620/Source/: system_max32620.c
  group board/max3510x
    ../board/max35103evkit2/max3510x/: max3510x.c max3510x.h max3510x_regs.h
